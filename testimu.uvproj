# Keil uVision project testimu.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: testimu +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\Quest16480;.\STM32F4xx_StdPeriph_Driver\inc;.\Matlab;F:\R2016a\extern\include;F:\R2016a\simulink\include;F:\R2016a\rtw\c\src;F:\R2016a\rtw\c\src\ext_mode\common;F:\R2016a\rtw\c\ert;..\Quest16405_GPS_IMU2.2;.\result
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: startup_stm32f40_41xxx.s driver.c main.c system_stm32f4xx.c system_timetick.c genDataGetProcess.c initialize.c
  group STM32F4XX
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_dma.c
  group Matlab
    ./Matlab/: IMU_Quest.c IMU_Quest_data.c rt_atan2_snf.c rt_nonfinite.c rt_pow_snf.c rtGetInf.c rtGetNaN.c
  group result
    ./result/: Cbn_31.c Cbn_31_initialize.c Cbn_31_terminate.c diag.c eye.c insgps_v5_1.c mrdivide.c normC.c power.c skew_mat3.c
